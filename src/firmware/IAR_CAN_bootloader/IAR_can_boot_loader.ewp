# IAR project IAR_can_boot_loader.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x20
  General.SCCStackSize: 0x40
  General.SCRStackSize: 32
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: can64 AT90CAN64
  ICCAVR.newCCIncludePaths: ; ..\; ..\libraries\; ..\libraries\lib_mcu\; ..\libraries\lib_mcu\can\; ..\libraries\lib_mcu\flash\; ..\libraries\lib_mcu\eeprom\; ..\libraries\lib_board\; ..\libraries\lib_module\; ..\libraries\lib_module\isp\
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: can64_iar_can_bootloader_link.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.GenDeviceSelectMenu: 0 -v0, Max 256 byte data, 8 Kbyte code
  ICCAVR.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../libraries/lib_mcu/can/: can_drv.c can_isp_protocol.c reduced_can_lib.c
    ../libraries/lib_mcu/eeprom/: eeprom_lib.c
    ../libraries/lib_mcu/flash/: flash_boot_drv.c flash_boot_lib.c
    ../libraries/lib_module/isp/: isp_lib.c
    ./: main_can_boot_loader.c
